# Keil uVision project stm32f429.uvprojx, settings and files
target STM32F429ZI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F429ZI
  c include: ..\01-Creating_Tasks;..\00-StdPeriph_Lib_V1.7.1\CMSIS\Include;..\00-StdPeriph_Lib_V1.7.1\CMSIS\Device\Include;..\00-StdPeriph_Lib_V1.7.1\StdPeriph_Driver\inc;..\00-FreeRTOS_V9.0.0\include;..\00-FreeRTOS_V9.0.0\portable\Keil\ARM_CM4F;..\00-Majerle_Tilen
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_it.c
  group Startup
    ./: system_stm32f4xx.c
    ../00-StdPeriph_Lib_V1.7.1/CMSIS/Device/Source/arm/: startup_stm32f429_439xx.s
  group StdPeriph_Driver
    ../00-StdPeriph_Lib_V1.7.1/StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c
  group FreeRTOS/source
    ../00-FreeRTOS_V9.0.0/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../00-FreeRTOS_V9.0.0/portable/Keil/ARM_CM4F/: port.c
    ../00-FreeRTOS_V9.0.0/portable/MemMang/: heap_4.c
  group Majerle_Tilen
    ../00-Majerle_Tilen/: tm_stm32f4_delay.c tm_stm32f4_disco.c tm_stm32f4_exti.c tm_stm32f4_usart.c tm_stm32f4_gpio.c
